Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Numéro du projet
Time: 2018-06-11T13:08:03
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.4.0.0 - Alternate UI 16.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Jun 11 13:08:03 2018 * Host: JB-MSI * Database: C:\Users\JB\AppData\Local\Temp\{14C0D809-A8F7-4202-8461-F8529516A14B}\ifc * Database version: 5507 * Database creation date: Mon Jun 11 13:08:01 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Jun 11 13:08:01 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Jun 11 13:08:01 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro du projet
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 42, 12, 46, 804504; RefLongitude: -71, -2, 0, -602416; RefElevation: 0 mm
Autre - Adresse du projet: ## Rue Ville, Code postal; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: ## Rue Ville, Code postal; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuildingStorey, Niveau 1
LongName: Niveau 1; Elevation: 0 mm
Graphismes(Type) - Couleur: 0; Epaisseur des lignes: 1; Motif des lignes: Centre; Symbole: M_Marqueur de niveau - Cercle: M_Marqueur de niveau - Cercle; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Pointe 8 mm
Autre - Catégorie: Niveaux; Famille: Niveau: Pointe 8 mm; Famille et type: Niveau: Pointe 8 mm; ID du type: Niveau: Pointe 8 mm; Type: Niveau: Pointe 8 mm
Contraintes - Elévation: 0 mm
Cotes - Hauteur de calcul: 0 mm
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 1; Structure: no
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet

# IfcBuildingElementProxy: Compteur gaz G10, Gaz naturel – Compteur:Compteur gaz G10:212521
In: Niveau 1
Type - Material: GRDF Gris, GRDF Jaune, GRDF Blanc
Type - Autre(Type) - Catégorie: Equipement de génie climatique; A Ecartement connecteurs: 110 mm; C Positionement connecteurs: 70 mm; Nom de la famille: Gaz naturel – Compteur
Type - Contraintes(Type) - Calibre: 10; Debit: 0.156954 m3/s; DN Amont: 32 mm; DN Aval: 32 mm; Hauteur: 375 mm; Largeur: 355 mm; Profondeur: 225 mm; Technologie: Membrane
Type - Données d'identification(Type) - Nom du type: Compteur gaz G10
Type - Génie climatique(Type) - Débit (L/s): 0 m3/s
Type - Matériaux et finitions(Type) - Bague: GRDF Gris; Capot: GRDF Jaune; Corps du coffret: GRDF Blanc
Pset_BuildingElementProxyCommon - Reference: Compteur gaz G10
Autre - Catégorie: Equipement de génie climatique; Famille: Gaz naturel – Compteur: Compteur gaz G10; Famille et type: Gaz naturel – Compteur: Compteur gaz G10; H: 375 mm; ID du type: Gaz naturel – Compteur: Compteur gaz G10; L: 355 mm; N° dans PTG/PTGE: 0; Non Gazpar: no; Organe de coupure individuelle: yes; P: 225 mm; Poids (kg): 0; Positionement connectuers: 0 mm; Type: Gaz naturel – Compteur: Compteur gaz G10
Contraintes - Décalage: 0 mm; Hôte: Niveau : Niveau 1; Lien vers les objets génériques au gaz naturel: https://cegibat.grdf.fr/dossier-techniques/conception-batiments/objets-bim-gaz-naturel; Niveau: Niveau: Niveau 1
Cotes - Surface: 0.548802 m2; Volume: 0.0268527 m3
Données d'identification - Identifiant: 8
Génie climatique - Classification du système: Non défini; Débit MAX (L/s): 0 m3/s; Pression Amont (Pa): 0 Pa; Pression Amont MAX (Pa): 0 Pa; Pression Aval (Pa): 0 Pa; Pression Aval MAX (Pa): 0 Pa
Phase de construction - Phase de création: Nouvelle construction
